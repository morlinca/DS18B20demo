# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W Series STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c one_wire.c one_wire.h desply.c desply.h ds18b20.c ds18b20.h ttl9600.c ttl9600.h
